# Keil uVision project nfc_fm17520.uvprojx, settings and files
target nfc_fm17520 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Mini58ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.2.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\..\Library\StdDriver\inc;..\..\project;..\..\source;..\..\des
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini58Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c spi.c i2c.c timer.c wdt.c wwdt.c
  group User
    ../: main.c
  group source
    ../../source/: system_config.c spi_driver.c fm175xx.c type_a.c ultralight.c nfc_app.c i2c_driver.c
  group des
    ../../des/: des.c des_enc.c ecb_enc.c set_key.c
software components: CMSIS:CORE 5.0.1
